# IAR project Project.ewp, settings and files
configuration STM32F4-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STM32F4_DISCO
  ICCARM.CCDiagSuppress: Pe188,Pa093
  ICCARM.CCIncludePath2: ..\Inc; ..\..\stm32cubef4\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\stm32cubef4\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\stm32cubef4\Drivers\BSP\STM32F4-Discovery; ..\..\stm32cubef4\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\stm32cubef4\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\stm32cubef4\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group Drivers/RTOS
    ../../stm32cubef4/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../stm32cubef4/Utilities/CPU/: cpu_utils.c
    ../../stm32cubef4/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../stm32cubef4/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../stm32cubef4/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../stm32cubef4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Header
    ../Inc/: cq.h FreeRTOSConfig.h main.h stm32f4xx_hal_conf.h trace.h
  group Source
    ../Src/: ansi.c calc_imbal.c can.c cooler.c debug.c display.c dsp.c fram.c gpio.c gyrozen_motor.c gyrozen_protocol.c input.c main.c mainui.c manageui.c menu.c myprotocol.c mytask.c myuart.c nexd_motor.c old_wince_lcd.c rotor_comm.c run.c temp.c timer.c uartstdio.c utility.c
